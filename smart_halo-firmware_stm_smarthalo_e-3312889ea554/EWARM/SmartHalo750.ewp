# IAR project SmartHalo750.ewp, settings and files
configuration STM32F7508_DISCO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F750N8 ST STM32F750N8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F750xx; USE_BPP=24
  ICCARM.CCIncludePath2: ../Core/Inc; ../TouchGFX/target; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/texts/include; ../TouchGFX/generated/images/include; ../TouchGFX/generated/gui_generated/include; ../TouchGFX/gui/include; ..\Middlewares\ST\TouchGFX\touchgfx\framework\include; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Drivers/CMSIS/Include; ..\Middlewares\ST\TouchGFX\touchgfx\framework\include; ..\Middlewares\ST\TouchGFX\touchgfx\framework\include; ..\Drivers\BSP\STM32F7508-Discovery; ..\Middlewares\ST\TouchGFX\touchgfx\framework\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: STM32F7508_DISCO.hex
  ILINK.IlinkOutputFile: STM32F7508_DISCO.out
  ILINK.IlinkKeepSymbols: Bootloader
  ILINK.IlinkIcfFile: stm32f750xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f750xx.s
  group Application/User/Core
    ../Core/Src/: freertos.c main.cpp stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c main.cpp freertos.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: BoardConfiguration.cpp GPIO.cpp HW_Init.cpp STM32F7DMA.cpp STM32F7HAL.cpp STM32F7Instrumentation.cpp STM32F7TouchController.cpp BoardConfiguration.cpp GPIO.cpp STM32F7DMA.cpp STM32F7HAL.cpp STM32F7TouchController.cpp STM32F7Instrumentation.cpp HW_Init.cpp
  group Application/User/TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp Font_rubikbold_100_4bpp.cpp Font_rubikbold_10_4bpp.cpp Font_rubikbold_15_4bpp.cpp Font_rubikbold_20_4bpp.cpp Font_rubikbold_30_4bpp.cpp Font_rubikbold_40_4bpp.cpp Font_rubikbold_60_4bpp.cpp FontGetters.cpp Kerning_rubikbold_100_4bpp.cpp Kerning_rubikbold_10_4bpp.cpp Kerning_rubikbold_15_4bpp.cpp Kerning_rubikbold_20_4bpp.cpp Kerning_rubikbold_30_4bpp.cpp Kerning_rubikbold_40_4bpp.cpp Kerning_rubikbold_60_4bpp.cpp Table_rubikbold_100_4bpp.cpp Table_rubikbold_10_4bpp.cpp Table_rubikbold_15_4bpp.cpp Table_rubikbold_20_4bpp.cpp Table_rubikbold_30_4bpp.cpp Table_rubikbold_40_4bpp.cpp Table_rubikbold_60_4bpp.cpp
  group Application/User/TouchGFX/generated/gui_generated/alarmeastsplash_screen
    ../TouchGFX/generated/gui_generated/src/alarmeastsplash_screen/: AlarmEastSplashViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/alarmscreen_screen
    ../TouchGFX/generated/gui_generated/src/alarmscreen_screen/: AlarmScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/alarmwestsplash_screen
    ../TouchGFX/generated/gui_generated/src/alarmwestsplash_screen/: AlarmWestSplashViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/assistanteastsplash_screen
    ../TouchGFX/generated/gui_generated/src/assistanteastsplash_screen/: AssistantEastSplashViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/assistantscreen_screen
    ../TouchGFX/generated/gui_generated/src/assistantscreen_screen/: AssistantScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/common
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/containers
    ../TouchGFX/generated/gui_generated/src/containers/: AlarmMenuItemBase.cpp AssistantMenuItemBase.cpp AssistIconBase.cpp FeatureCarrosselDotsBase.cpp LargeStatusBarBase.cpp LightMenuItemBase.cpp NavMenuItemBase.cpp NavOptionMenuItemBase.cpp SelectedAlarmMenuItemBase.cpp SelectedAssistantMenuItemBase.cpp SelectedLightMenuItemBase.cpp SelectedNavMenuItemBase.cpp SelectedNavOptionMenuItemBase.cpp StatusBarBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/fitnesseastsplash_screen
    ../TouchGFX/generated/gui_generated/src/fitnesseastsplash_screen/: FitnessEastSplashViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/fitnessscreen_screen
    ../TouchGFX/generated/gui_generated/src/fitnessscreen_screen/: FitnessScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/fitnesswestsplash_screen
    ../TouchGFX/generated/gui_generated/src/fitnesswestsplash_screen/: FitnessWestSplashViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/homescreen_screen
    ../TouchGFX/generated/gui_generated/src/homescreen_screen/: HomeScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/homesplash_screen
    ../TouchGFX/generated/gui_generated/src/homesplash_screen/: HomeSplashViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/homewestsplash_screen
    ../TouchGFX/generated/gui_generated/src/homewestsplash_screen/: HomeWestSplashViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/lighteastsplash_screen
    ../TouchGFX/generated/gui_generated/src/lighteastsplash_screen/: LightEastSplashViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/lightscreen_screen
    ../TouchGFX/generated/gui_generated/src/lightscreen_screen/: LightScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/lightwestsplash_screen
    ../TouchGFX/generated/gui_generated/src/lightwestsplash_screen/: LightWestSplashViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/navigationeastsplash_screen
    ../TouchGFX/generated/gui_generated/src/navigationeastsplash_screen/: NavigationEastSplashViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/navigationmenu_screen
    ../TouchGFX/generated/gui_generated/src/navigationmenu_screen/: NavigationMenuViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/navigationoptions_screen
    ../TouchGFX/generated/gui_generated/src/navigationoptions_screen/: NavigationOptionsViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/navigationscreen_screen
    ../TouchGFX/generated/gui_generated/src/navigationscreen_screen/: NavigationScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/navigationwestsplash_screen
    ../TouchGFX/generated/gui_generated/src/navigationwestsplash_screen/: NavigationWestSplashViewBase.cpp
  group Application/User/TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: alarm.cpp alarmIcon.cpp alarmIcon00.cpp alarmIcon00Selected.cpp alarmIcon01.cpp alarmIcon01Selected.cpp assistant.cpp assistantIcon00.cpp assistantIcon00Selected.cpp assistantIcon01.cpp assistantIcon01Selected.cpp assistGardientTop.cpp assistGradientBottom.cpp assistIcon.cpp assistLevelBackgound.cpp assitantIcon.cpp batteryCase.cpp BitmapDatabase.cpp blinkoff.cpp blinkon.cpp emptyIcon.cpp fitnessIcon.cpp frameDirection.cpp light.cpp lightIcon.cpp lightIcon00.cpp lightIcon00Selected.cpp lightIcon01.cpp lightIcon01Selected.cpp lightoff.cpp lighton.cpp location.cpp menuBackground.cpp menuSelectedBackground.cpp moreFitness.cpp moreNavigation.cpp navFadeTail.cpp navIcon.cpp navIcon00.cpp navIcon00Selected.cpp navIcon01.cpp navIcon01Selected.cpp navIcon02.cpp navIcon02Selected.cpp navIcon03.cpp navIcon03Selected.cpp navIcon10.cpp navIcon10Selected.cpp navIcon11.cpp navIcon11Selected.cpp Rectangleselected.cpp Rectangleunselected1.cpp Rectangleunselected2.cpp Rectangleunselected3.cpp
  group Application/User/TouchGFX/generated/images/__designer
    ../TouchGFX/generated/images/src/__designer/: blue_check_buttons_check_re_mark_inactive.cpp
  group Application/User/TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/alarmeastsplash_screen
    ../TouchGFX/gui/src/alarmeastsplash_screen/: AlarmEastSplashPresenter.cpp AlarmEastSplashView.cpp
  group Application/User/TouchGFX/gui/alarmscreen_screen
    ../TouchGFX/gui/src/alarmscreen_screen/: AlarmScreenPresenter.cpp AlarmScreenView.cpp
  group Application/User/TouchGFX/gui/alarmwestsplash_screen
    ../TouchGFX/gui/src/alarmwestsplash_screen/: AlarmWestSplashPresenter.cpp AlarmWestSplashView.cpp
  group Application/User/TouchGFX/gui/assistanteastsplash_screen
    ../TouchGFX/gui/src/assistanteastsplash_screen/: AssistantEastSplashPresenter.cpp AssistantEastSplashView.cpp
  group Application/User/TouchGFX/gui/assistantscreen_screen
    ../TouchGFX/gui/src/assistantscreen_screen/: AssistantScreenPresenter.cpp AssistantScreenView.cpp
  group Application/User/TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp
  group Application/User/TouchGFX/gui/containers
    ../TouchGFX/gui/src/containers/: AlarmMenuItem.cpp AssistantMenuItem.cpp AssistIcon.cpp FeatureCarrosselDots.cpp LargeStatusBar.cpp LightMenuItem.cpp NavMenuItem.cpp NavOptionMenuItem.cpp SelectedAlarmMenuItem.cpp SelectedAssistantMenuItem.cpp SelectedLightMenuItem.cpp SelectedNavMenuItem.cpp SelectedNavOptionMenuItem.cpp StatusBar.cpp
  group Application/User/TouchGFX/gui/fitnesseastsplash_screen
    ../TouchGFX/gui/src/fitnesseastsplash_screen/: FitnessEastSplashPresenter.cpp FitnessEastSplashView.cpp
  group Application/User/TouchGFX/gui/fitnessscreen_screen
    ../TouchGFX/gui/src/fitnessscreen_screen/: FitnessScreenPresenter.cpp FitnessScreenView.cpp
  group Application/User/TouchGFX/gui/fitnesswestsplash_screen
    ../TouchGFX/gui/src/fitnesswestsplash_screen/: FitnessWestSplashPresenter.cpp FitnessWestSplashView.cpp
  group Application/User/TouchGFX/gui/homescreen_screen
    ../TouchGFX/gui/src/homescreen_screen/: HomeScreenPresenter.cpp HomeScreenView.cpp
  group Application/User/TouchGFX/gui/homesplash_screen
    ../TouchGFX/gui/src/homesplash_screen/: HomeSplashPresenter.cpp HomeSplashView.cpp
  group Application/User/TouchGFX/gui/homewestsplash_screen
    ../TouchGFX/gui/src/homewestsplash_screen/: HomeWestSplashPresenter.cpp HomeWestSplashView.cpp
  group Application/User/TouchGFX/gui/lighteastsplash_screen
    ../TouchGFX/gui/src/lighteastsplash_screen/: LightEastSplashPresenter.cpp LightEastSplashView.cpp
  group Application/User/TouchGFX/gui/lightscreen_screen
    ../TouchGFX/gui/src/lightscreen_screen/: LightScreenPresenter.cpp LightScreenView.cpp
  group Application/User/TouchGFX/gui/lightwestsplash_screen
    ../TouchGFX/gui/src/lightwestsplash_screen/: LightWestSplashPresenter.cpp LightWestSplashView.cpp
  group Application/User/TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group Application/User/TouchGFX/gui/navigationeastsplash_screen
    ../TouchGFX/gui/src/navigationeastsplash_screen/: NavigationEastSplashPresenter.cpp NavigationEastSplashView.cpp
  group Application/User/TouchGFX/gui/navigationmenu_screen
    ../TouchGFX/gui/src/navigationmenu_screen/: NavigationMenuPresenter.cpp NavigationMenuView.cpp
  group Application/User/TouchGFX/gui/navigationoptions_screen
    ../TouchGFX/gui/src/navigationoptions_screen/: NavigationOptionsPresenter.cpp NavigationOptionsView.cpp
  group Application/User/TouchGFX/gui/navigationscreen_screen
    ../TouchGFX/gui/src/navigationscreen_screen/: NavigationScreenPresenter.cpp NavigationScreenView.cpp
  group Application/User/TouchGFX/gui/navigationwestsplash_screen
    ../TouchGFX/gui/src/navigationwestsplash_screen/: NavigationWestSplashPresenter.cpp NavigationWestSplashView.cpp
  group Drivers/BSP
    ../Drivers/BSP/Components/ft5336/: ft5336.c
    ../Drivers/BSP/STM32F7508-Discovery/: stm32f7508_discovery.c stm32f7508_discovery_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s port.c portasm.s
  group Middlewares/TouchGFX
    ../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers.cpp OSWrappers.cpp
    ../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m7/IAR8.x/: touchgfx_core_release.a touchgfx_core_release.a

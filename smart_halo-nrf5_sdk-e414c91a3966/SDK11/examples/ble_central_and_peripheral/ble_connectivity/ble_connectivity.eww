<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10040\ser_s132_spi\iar\ble_connectivity_s132_spi_pca10040.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\ser_s130_hci\iar\ble_connectivity_s130_hci_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\ser_s130_spi\iar\ble_connectivity_s130_spi_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10040\ser_s132_hci\iar\ble_connectivity_s132_hci_pca10040.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10036\ser_s132_hci\iar\ble_connectivity_s132_hci_pca10036.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10036\ser_s132_spi\iar\ble_connectivity_s132_spi_pca10036.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\ser_s130_uart\iar\ble_connectivity_s130_uart_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10036\ser_s132_uart\iar\ble_connectivity_s132_uart_pca10036.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10040\ser_s132_uart\iar\ble_connectivity_s132_uart_pca10040.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10040\ser_s132_spi_5W\iar\ble_connectivity_s132_spi_5W_pca10040.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\ser_s130_spi_5W\iar\ble_connectivity_s130_spi_5W_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10036\ser_s132_spi_5W\iar\ble_connectivity_s132_spi_5W_pca10036.ewp</path>
  </project>
  <batchBuild/>
</workspace>
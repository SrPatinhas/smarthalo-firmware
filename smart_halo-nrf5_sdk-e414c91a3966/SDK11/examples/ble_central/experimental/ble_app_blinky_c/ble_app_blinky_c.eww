<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10028\s130\iar\ble_app_blinky_c_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10040\s132\iar\ble_app_blinky_c_pca10040.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10036\s132\iar\ble_app_blinky_c_pca10036.ewp</path>
  </project>
  <batchBuild/>
</workspace>
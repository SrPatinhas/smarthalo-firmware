<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10028\iar\twi_sensor_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10040\iar\twi_sensor_pca10040.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10036\iar\twi_sensor_pca10036.ewp</path>
  </project>
  <batchBuild/>
</workspace>
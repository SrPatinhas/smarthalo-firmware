<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\speed\auto\pca10040\iar\ant_bsc_tx_speed_auto_s212_pca10040.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\speed\auto\pca10036\iar\ant_bsc_tx_speed_auto_s212_pca10036.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\speed\button\pca10036\iar\ant_bsc_tx_speed_button_s212_pca10036.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\speed\button\pca10040\iar\ant_bsc_tx_speed_button_s212_pca10040.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\cadence\auto\pca10036\iar\ant_bsc_tx_cadence_auto_s212_pca10036.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\cadence\auto\pca10040\iar\ant_bsc_tx_cadence_auto_s212_pca10040.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\combined\auto\pca10040\iar\ant_bsc_tx_combined_auto_s212_pca10040.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\combined\auto\pca10036\iar\ant_bsc_tx_combined_auto_s212_pca10036.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\cadence\button\pca10040\iar\ant_bsc_tx_cadence_button_s212_pca10040.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\cadence\button\pca10036\iar\ant_bsc_tx_cadence_button_s212_pca10036.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\combined\button\pca10040\iar\ant_bsc_tx_combined_button_s212_pca10040.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\combined\button\pca10036\iar\ant_bsc_tx_combined_button_s212_pca10036.ewp</path>
  </project>
  <batchBuild/>
</workspace>
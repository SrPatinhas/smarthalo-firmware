<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10040\iar\experimental_ant_shared_channel_slave_s212_pca10040.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10036\iar\experimental_ant_shared_channel_slave_s212_pca10036.ewp</path>
  </project>
  <batchBuild/>
</workspace>
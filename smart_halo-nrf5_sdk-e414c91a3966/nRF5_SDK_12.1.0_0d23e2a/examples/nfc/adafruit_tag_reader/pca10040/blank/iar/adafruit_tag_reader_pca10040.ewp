# IAR project adafruit_tag_reader_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; NRF52832; BOARD_PCA10040; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_30; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_53; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_62; NRF52_PAN_63; NRF52_PAN_64; CONFIG_GPIO_AS_PINRESET; NRF52; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\drivers_nrf\twi_master; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\hardfault; ..\..\..\..\..\..\components\libraries\hardfault\nrf52; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\nfc\ndef\generic\message; ..\..\..\..\..\..\components\nfc\ndef\generic\record; ..\..\..\..\..\..\components\nfc\ndef\parser\message; ..\..\..\..\..\..\components\nfc\ndef\parser\record; ..\..\..\..\..\..\components\nfc\t2t_parser; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\bsp; ..\..\..; ..\..\..\..\..\..\external\nfc_adafruit_library; ..\..\..\..\..\..\external\segger_rtt; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: adafruit_tag_reader_pca10040.hex
  ILINK.IlinkOutputFile: adafruit_tag_reader_pca10040.out
  ILINK.IlinkIcfFile: adafruit_tag_reader_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_iar.c
    ../../../../../../components/libraries/hardfault/: hardfault_implementation.c
  group Third Parties
    ../../../../../../external/nfc_adafruit_library/: adafruit_pn532.c
  group Documentation
    ../../../: license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group nRF_NFC
    ../../../../../../components/nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../../../../../../components/nfc/ndef/parser/message/: nfc_ndef_msg_parser.c nfc_ndef_msg_parser_local.c
    ../../../../../../components/nfc/ndef/generic/record/: nfc_ndef_record.c
    ../../../../../../components/nfc/ndef/parser/record/: nfc_ndef_record_parser.c
    ../../../../../../components/nfc/t2t_parser/: nfc_t2t_parser.c

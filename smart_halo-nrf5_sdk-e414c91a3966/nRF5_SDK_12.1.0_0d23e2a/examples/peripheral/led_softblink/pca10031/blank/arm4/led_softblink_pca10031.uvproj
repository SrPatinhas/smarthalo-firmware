# Keil uVision project led_softblink_pca10031.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51422 BOARD_PCA10031 BSP_DEFINES_ONLY NRF51 SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config\led_softblink_pca10031;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\bsp;..\..\..;..\config
  asm define: NRF51422 BOARD_PCA10031 BSP_DEFINES_ONLY NRF51 SWI_DISABLE0
  asm misc: --cpreproc_opts=-DNRF51422,-DBOARD_PCA10031,-DBSP_DEFINES_ONLY,-DNRF51,-DSWI_DISABLE0
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/led_softblink/: led_softblink.c
    ../../../../../../components/libraries/low_power_pwm/: low_power_pwm.c

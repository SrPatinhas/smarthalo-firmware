# IAR project led_softblink_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NRF52832; BOARD_PCA10040; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_30; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_53; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_62; NRF52_PAN_63; NRF52_PAN_64; CONFIG_GPIO_AS_PINRESET; BSP_DEFINES_ONLY; NRF52; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\..\config\led_softblink_pca10040; ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\led_softblink; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\low_power_pwm; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\bsp; ..\..\..; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: led_softblink_pca10040.hex
  ILINK.IlinkOutputFile: led_softblink_pca10040.out
  ILINK.IlinkIcfFile: led_softblink_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/led_softblink/: led_softblink.c
    ../../../../../../components/libraries/low_power_pwm/: low_power_pwm.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
  group Documentation
    ../../../: license.txt

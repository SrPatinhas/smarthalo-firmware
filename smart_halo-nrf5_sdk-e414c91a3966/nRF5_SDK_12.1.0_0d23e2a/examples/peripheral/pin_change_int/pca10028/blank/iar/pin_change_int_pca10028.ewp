# IAR project pin_change_int_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NRF51422; BOARD_PCA10028; BSP_DEFINES_ONLY; NRF51
  ICCARM.CCIncludePath2: ..\..\..\config\pin_change_int_pca10028; ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\bsp; ..\..\..; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NRF51422; BOARD_PCA10028; BSP_DEFINES_ONLY; NRF51
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: pin_change_int_pca10028.hex
  ILINK.IlinkOutputFile: pin_change_int_pca10028.out
  ILINK.IlinkIcfFile: pin_change_int_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c nrf_assert.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group Documentation
    ../../../: license.txt

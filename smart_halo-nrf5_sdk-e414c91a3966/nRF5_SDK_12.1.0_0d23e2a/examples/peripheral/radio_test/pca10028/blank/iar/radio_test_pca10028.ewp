# IAR project radio_test_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NRF51422; BOARD_PCA10028; BSP_DEFINES_ONLY; NRF51
  ICCARM.CCIncludePath2: ..\..\..\config\radio_test_pca10028; ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\bsp; ..\..\..; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NRF51422; BOARD_PCA10028; BSP_DEFINES_ONLY; NRF51
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: radio_test_pca10028.hex
  ILINK.IlinkOutputFile: radio_test_pca10028.out
  ILINK.IlinkIcfFile: radio_test_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Application
    ../../../: main.c radio_test.c
    ../config/: sdk_config.h
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/uart/: app_uart_fifo.c retarget.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group Documentation
    ../../../: license.txt

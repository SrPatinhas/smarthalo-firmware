# Keil uVision project experimental_ant_shared_channel_master_to_master_pca10040_s332.uvproj, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD ANT_STACK_SUPPORT_REQD NRF52832 S332 NRF_SD_BLE_API_VERSION=3 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config\experimental_ant_shared_channel_master_to_master_pca10040_s332;..\..\..\config;..\..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\..\components\ant\ant_stack_config;..\..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\..\..\components\libraries\hardfault\nrf52;..\..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\..\..\components\softdevice\s332\headers;..\..\..\..\..\..\..\..\components\softdevice\s332\headers\nrf52;..\..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\..\bsp;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DANT_STACK_SUPPORT_REQD,-DNRF52832,-DS332,-DNRF_SD_BLE_API_VERSION=3,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_30,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_53,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_62,-DNRF52_PAN_63,-DNRF52_PAN_64,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x29000 size 0x57000
  memory RVCT9: RAM 0x20003f58 size 0xc0a8
  group Application
    ../../../: ant_phone_connection.c asc_coordinator.c asc_device_registry.c asc_master.c asc_master_to_master.c asc_pages.c ble_controllable_hub.c ble_phone_connection.c main.c n5sk_button.c n5sk_led.c
    ../config/: sdk_config.h
  group Board Support
    ../../../../../../../bsp/: bsp.c
  group Device
    ../../../../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../../../../components/toolchain/: system_nrf52.c
  group Documentation
    ../../../: license.txt
  group nRF_ANT
    ../../../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
  group nRF_BLE
    ../../../../../../../../components/ble/common/: ble_advdata.c ble_srv_common.c
  group nRF_Drivers
    ../../../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_Libraries
    ../../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../../../../../../../../components/libraries/hardfault/: hardfault_implementation.c
  group nRF_SoftDevice
    ../../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c

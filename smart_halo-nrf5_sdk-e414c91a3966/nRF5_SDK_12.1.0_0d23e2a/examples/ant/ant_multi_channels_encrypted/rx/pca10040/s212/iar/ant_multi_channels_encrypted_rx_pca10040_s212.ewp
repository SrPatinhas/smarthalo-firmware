# IAR project ant_multi_channels_encrypted_rx_pca10040_s212.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ANT_STACK_SUPPORT_REQD; NRF52832; S212; BOARD_PCA10040; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_30; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_53; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_62; NRF52_PAN_63; NRF52_PAN_64; CONFIG_GPIO_AS_PINRESET; NRF52; SOFTDEVICE_PRESENT; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\..\config\ant_multi_channels_encrypted_rx_pca10040_s212; ..\..\..\config; ..\..\..\..\..\..\..\components; ..\..\..\..\..\..\..\components\ant\ant_channel_config; ..\..\..\..\..\..\..\components\ant\ant_encryption; ..\..\..\..\..\..\..\components\ant\ant_search_config; ..\..\..\..\..\..\..\components\ant\ant_stack_config; ..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\components\libraries\hardfault; ..\..\..\..\..\..\..\components\libraries\hardfault\nrf52; ..\..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\..\components\softdevice\s212\headers; ..\..\..\..\..\..\..\components\softdevice\s212\headers\nrf52; ..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\bsp; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ant_multi_channels_encrypted_rx_pca10040_s212.hex
  ILINK.IlinkOutputFile: ant_multi_channels_encrypted_rx_pca10040_s212.out
  ILINK.IlinkIcfFile: ant_multi_channels_encrypted_rx_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_iar.c
    ../../../../../../../components/libraries/hardfault/: hardfault_implementation.c
  group Documentation
    ../../../: license.txt
  group nRF_Drivers
    ../../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_ANT
    ../../../../../../../components/ant/ant_channel_config/: ant_channel_config.c
    ../../../../../../../components/ant/ant_encryption/: ant_encrypt_config.c ant_encrypt_negotiation_slave.c
    ../../../../../../../components/ant/ant_search_config/: ant_search_config.c
    ../../../../../../../components/ant/ant_stack_config/: ant_stack_config.c
  group Board Support
    ../../../../../../bsp/: bsp.c
  group Application
    ../../../: ant_multi_channels_encrypted_rx.c main.c
    ../config/: sdk_config.h
  group Device
    ../../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../../components/toolchain/: system_nrf52.c
  group nRF_SoftDevice
    ../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
